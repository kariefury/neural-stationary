*PulseLoop
 .include sky130nm.lib
 Xpg1 sNoise outB outA pos_supply neg_supply pgNeg
 Xpg2 outA sNoise outB pos_supply neg_supply pgNeg
 * Separate circuit for neg pos
 Xpg3 sNoise NPoutB NPoutA pos_supply neg_supply pgNeg
 Xpg4 NPoutA sNoise NPoutB pos_supply neg_supply pgNegPos
 * Phase Circuit
 Xpg5 NPoutA upB upA pos_supply neg_supply pgNeg
 Xpg6 upA outA upB pos_supply neg_supply pgNeg
 v3 pos_supply 0 1.8
 v4 neg_supply 0 0.0
 v2 sNoise 0 dc 0 trrandom (2 20p 0 0.6 0.1)
.control
 *plot v(outA) v(outB) v(sNoise)
 *plot i(v3)
 tran 10ps 23.547880690737838ns
 meas tran responseTimeA1 WHEN v(outA)=1.2 CROSS=1
 meas tran responseTimeA2 WHEN v(outA)=1.2 CROSS=2
 meas tran responseTimeA3 WHEN v(outA)=1.2 CROSS=3
 meas tran responseTimeA4 WHEN v(outA)=1.2 CROSS=4
 meas tran responseTimeB1 WHEN v(outB)=1.2 CROSS=1
 meas tran responseTimeB2 WHEN v(outB)=1.2 CROSS=2
 meas tran responseTimeB3 WHEN v(outB)=1.2 CROSS=3
 meas tran responseTimeB4 WHEN v(outB)=1.2 CROSS=4
 meas tran NPresponseTimeA1 WHEN v(NPoutA)=1.2 CROSS=1
 meas tran NPresponseTimeA2 WHEN v(NPoutA)=1.2 CROSS=2
 meas tran NPresponseTimeA3 WHEN v(NPoutA)=1.2 CROSS=3
 meas tran NPresponseTimeA4 WHEN v(NPoutA)=1.2 CROSS=4
 meas tran NPresponseTimeB1 WHEN v(NPoutB)=1.2 CROSS=1
 meas tran NPresponseTimeB2 WHEN v(NPoutB)=1.2 CROSS=2
 meas tran NPresponseTimeB3 WHEN v(NPoutB)=1.2 CROSS=3
 meas tran NPresponseTimeB4 WHEN v(NPoutB)=1.2 CROSS=4
 meas tran responseTimeupA1 WHEN v(upA)=1.2 CROSS=1
 meas tran responseTimeupA2 WHEN v(upA)=1.2 CROSS=2
 meas tran responseTimeupA3 WHEN v(upA)=1.2 CROSS=3
 meas tran responseTimeupA4 WHEN v(upA)=1.2 CROSS=4
 meas tran responseTimeupB1 WHEN v(upB)=1.2 CROSS=1
 meas tran responseTimeupB2 WHEN v(upB)=1.2 CROSS=2
 meas tran responseTimeupB3 WHEN v(upB)=1.2 CROSS=3
 meas tran responseTimeupB4 WHEN v(upB)=1.2 CROSS=4
 let tdiff = responsetimea4-responsetimea1
 print tdiff
 meas tran iavg avg i(v3) FROM=responsetimea1 TO=responsetimea4
 print iavg
 let tdiffb = responsetimeB4-responsetimeB1
 print tdiffb
 meas tran iavgb avg i(v3) FROM=responsetimeb1 TO=responsetimeb4
 print iavgb
 .endc

 .subckt pgNeg2PosSeries Aneg Bpos Cpos x pow_supply gnd_supply

 xm1 pow_supply reset_loop critical_node pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n

 xm2 gnd_supply Aneg critical_node gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm11 pow_supply Cpos critical_node bc sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm10 bc Bpos critical_node pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n

 xm3 pow_supply critical_node invO pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm4 gnd_supply critical_node invO gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm14 pow_supply invO reset_loop pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm5 gnd_supply invO reset_loop gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm6 pow_supply invO xe pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm7 gnd_supply invO xe gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm8 pow_supply xe x pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm9 gnd_supply xe x gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n
 .ends pgNeg2PosSeries

 .subckt pgNegPos Aneg Bpos x pow_supply gnd_supply

 xm1 pow_supply reset_loop critical_node pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n

 xm2 gnd_supply Aneg critical_node gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm10 pow_supply Bpos critical_node pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n

 xm3 pow_supply critical_node invO pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm4 gnd_supply critical_node invO gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm4 pow_supply invO reset_loop pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm5 gnd_supply invO reset_loop gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm6 pow_supply invO xe pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm7 gnd_supply invO xe gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm8 pow_supply xe x pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm9 gnd_supply xe x gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n
 .ends pgNegPos

 .subckt pgNeg Aneg Bneg x pow_supply gnd_supply

 xm1 pow_supply reset_loop critical_node pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n

 xm2 gnd_supply Aneg critical_node gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm10 pow_supply Bneg critical_node gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm3 pow_supply critical_node invO pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm4 gnd_supply critical_node invO gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm4 pow_supply invO reset_loop pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm5 gnd_supply invO reset_loop gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm6 pow_supply invO xe pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm7 gnd_supply invO xe gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm8 pow_supply xe x pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm9 gnd_supply xe x gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n
 .ends pgNeg

 .subckt pgNeg3Parallel Aneg Bneg Cneg x pow_supply gnd_supply

 xm1 pow_supply reset_loop critical_node pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n

 xm2 gnd_supply Aneg critical_node gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm10 gnd_supply Bneg critical_node gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm11 gnd_supply Cneg critical_node gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm3 pow_supply critical_node invO pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm4 gnd_supply critical_node invO gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm14 pow_supply invO reset_loop pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm5 gnd_supply invO reset_loop gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm6 pow_supply invO xe pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm7 gnd_supply invO xe gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm8 pow_supply xe x pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm9 gnd_supply xe x gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n
 .ends pgNeg2Series

 .subckt pgNeg2Series Aneg Bneg BnegSeries x pow_supply gnd_supply

 xm1 pow_supply reset_loop critical_node pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n

 xm2 gnd_supply Aneg critical_node gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm10 gnd_supply Bneg critical_node bs sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm11 bs BnegSeries critical_node gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm3 pow_supply critical_node invO pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm4 gnd_supply critical_node invO gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm14 pow_supply invO reset_loop pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm5 gnd_supply invO reset_loop gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm6 pow_supply invO xe pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm7 gnd_supply invO xe gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm8 pow_supply xe x pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm9 gnd_supply xe x gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n
 .ends pgNeg2Series

 .subckt pgNegSeries Bneg BnegSeries x pow_supply gnd_supply

 xm1 pow_supply reset_loop critical_node pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n

 xm2 gnd_supply Aneg critical_node gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm10 gnd_supply Bneg critical_node bs sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm11 bs BnegSeries critical_node gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm3 pow_supply critical_node invO pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm4 gnd_supply critical_node invO gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm14 pow_supply invO reset_loop pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm5 gnd_supply invO reset_loop gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm6 pow_supply invO xe pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm7 gnd_supply invO xe gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm8 pow_supply xe x pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm9 gnd_supply xe x gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n
 .ends pgNegSeries

 .subckt pgNeg1 Aneg x pow_supply gnd_supply

 xm1 pow_supply reset_loop critical_node pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n

 xm2 gnd_supply Aneg critical_node gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm3 pow_supply critical_node invO pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm4 gnd_supply critical_node invO gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm14 pow_supply invO reset_loop pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm5 gnd_supply invO reset_loop gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm6 pow_supply invO xe pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm7 gnd_supply invO xe gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n

 xm8 pow_supply xe x pow_supply sky130_fd_pr__pfet_01v8 l=150n w=720n
 xm9 gnd_supply xe x gnd_supply sky130_fd_pr__nfet_01v8 l=150n w=360n
 .ends pgNeg1
